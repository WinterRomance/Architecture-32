# Keil uVision project ws2812.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: GD32F130C8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.6.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ws2812 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\User;..\Libraries\CMSIS;..\Libraries\CMSIS\GD\GD32F1x0\Include;..\Libraries\GD32F1x0_standard_peripheral\Include;..\BSP\WS2812\APPlication;..\BSP\WS2812\HAL;..\BSP\WS2812\LL;..\BSP\USART;..\BSP\TIMER;..\BSP\LED;..\BSP\WS2812\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../User/: gd32f1x0_it.c main.c systick.c
  group Application
    ../BSP/WS2812/APPlication/: ws2812_driver.c
    ../BSP/TIMER/: timer.c
    ../BSP/USART/: usart.c
    ../BSP/LED/: led.c
  group Driver_LL
    ../BSP/WS2812/LL/: ll_ws2812.c
  group Driver_HAL
    ../BSP/WS2812/HAL/: hal_ws2812.c
  group Libraries
    ../Libraries/GD32F1x0_standard_peripheral/Source/: gd32f1x0_adc.c gd32f1x0_cec.c gd32f1x0_cmp.c gd32f1x0_crc.c gd32f1x0_dac.c gd32f1x0_dbg.c gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_fwdgt.c gd32f1x0_gpio.c gd32f1x0_i2c.c gd32f1x0_misc.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_rtc.c gd32f1x0_spi.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_tsi.c gd32f1x0_usart.c gd32f1x0_wwdgt.c
  group CMSIS
    ../Libraries/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
    ../Libraries/CMSIS/GD/GD32F1x0/Source/ARM/: startup_gd32f1x0.s
